## boards/shields/Kconfig.shield
```kconfig
# No whitespace after the comma or in the keyboard name!
config SHIELD_EYELASH_CORNE
    def_bool $(shields_list_contains,eyelash_corne)
```
